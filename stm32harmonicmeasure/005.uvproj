# Keil uVision project 005.uvproj, settings and files
target 005 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 005
  c flags: Optim=1
  c include: D:\Keil\ARM\INC\ST\STM32F10x;.\driver;..\005;.\STM32F10x_DSP_Lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./: STM32F10x.s
    D:/Keil/ARM/RV31/LIB/ST/STM32F10x/: cortexm3_macro.s
  group user
    ./: main.c stm32f10x_it.c
  group FWLib
    D:/Keil/ARM/RV31/LIB/ST/STM32F10x/: stm32f10x_wwdg.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group DSP_Lib
    ./STM32F10x_DSP_Lib/src/asm/arm/: cr4_fft_1024_stm32.s cr4_fft_64_stm32.s cr4_fft_256_stm32.s
  group driver
    ./driver/: adc.c led.c rcc_config.c RS485.c
  group doc
    ./: readme.txt
