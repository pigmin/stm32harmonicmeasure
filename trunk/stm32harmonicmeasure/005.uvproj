# Keil uVision project 005.uvproj, settings and files
target 005 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 005
  c flags: Optim=1
  c define: VECT_TAB_FLASH
  c include: D:\Keil\ARM\INC\ST\STM32F10x;.\driver;..\stm32harmonicmeasure;.\STM32F10x_DSP_Lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group startup
    D:/Keil/ARM/RV31/LIB/ST/STM32F10x/: cortexm3_macro.s
    ./: stm32f10x_vector.s
  group user
    ./: main.c stm32f10x_it.c
  group FWLib
    D:/Keil/ARM/RV31/LIB/ST/STM32F10x/: stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
  group DSP_Lib
    ./STM32F10x_DSP_Lib/src/asm/arm/: cr4_fft_1024_stm32.s cr4_fft_64_stm32.s cr4_fft_256_stm32.s
  group driver
    ./driver/: adc.c led.c rcc_config.c RS485.c timer.c
  group doc
    ./: readme.txt
